options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10'
    stop: '5000'
    value: '1000'
  states: {}
- name: freq2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10'
    stop: '5000'
    value: '800'
  states: {}
- name: freq3
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10'
    stop: '5000'
    value: '300'
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: gain2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: gain3
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: gain
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: gain1
    freq: freq1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: gain2
    freq: freq2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: gain3
    freq: freq3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, packet_size_samples=1024):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Stream to Uniform Vector PMT',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.packet_size_samples = packet_size_samples
              self.message_port_register_out(pmt.intern("out"))
              self._buffer = np.array([], dtype=np.complex64)

          def work(self, input_items, output_items):
              in0 = input_items[0]

              if len(in0) == 0:
                  return 0

              # Buffer new input
              self._buffer = np.concatenate([self._buffer, in0])

              packets_emitted = 0
              while len(self._buffer) >= self.packet_size_samples:
                  # Slice out one packet
                  packet = self._buffer[:self.packet_size_samples]
                  # Remove from buffer
                  self._buffer = self._buffer[self.packet_size_samples:]
                  # Convert to PMT uniform vector
                  pkt_pmt = pmt.init_c32vector(self.packet_size_samples, packet.tolist())
                  self.message_port_pub(pmt.intern("out"), pkt_pmt)
                  packets_emitted += 1

              # Tell scheduler we consumed everything
              return len(input_items[0])
    packet_size_samples: '1024'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class pmt_to_stream(gr.basic_block):
          """
          Receives PMT uniform vectors (f32vector) on a message port, and outputs their
          samples as a stream of float32.
          """
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Uniform Vector PMT to Stream",
                  in_sig=[],
                  out_sig=[np.float32]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              self._buffer = np.array([], dtype=np.float32)

          def handle_msg(self, msg):
              # Expecting a uniform f32vector
              if pmt.is_f32vector(msg):
                  nitems = pmt.length(msg)
                  data = np.array([pmt.f32vector_ref(msg, i) for i in range(nitems)], dtype=np.float32)
                  # print(data[0])
                  # Buffer data for output
                  self._buffer = np.concatenate([self._buffer, data])

          def general_work(self, input_items, output_items):
              out = output_items[0]
              noutput_items = len(out)

              

              to_write = min(len(self._buffer), noutput_items)

              print (f'{len(self._buffer)}, {noutput_items}, {to_write}')
              if to_write > 0:
                  # print(to_write)
                  out[:to_write] = self._buffer[:to_write]
                  self._buffer = self._buffer[to_write:]
                  # print (f'{len(self._buffer)}')
                  # self.produce(0, to_write)
                  return to_write
              else:
                  # Nothing to output, tell scheduler we want more calls
                  return 0
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10240'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://localhost:5558
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
    type: float
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://localhost:5556
    timeout: '100'
    type: float
  states: {}
- name: zeromq_push_sink_0_1
  id: zeromq_push_sink
  parameters:
    address: tcp://localhost:5557
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_throttle2_0_0, '0']
- [analog_sig_source_x_0_0, '0', zeromq_push_sink_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_throttle2_0_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', zeromq_push_sink_0_0, '0']
- [analog_sig_source_x_0_0_1, '0', blocks_throttle2_0_0_1, '0']
- [analog_sig_source_x_0_0_1, '0', zeromq_push_sink_0_1, '0']
- [epy_block_0, out, zeromq_push_msg_sink_0, in]
- [epy_block_1, '0', qtgui_time_sink_x_0, '0']
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_pull_msg_source_0, out, epy_block_1, in]

metadata:
  file_format: 1
  grc_version: v3.10.11.0-1-gee27d6f3
